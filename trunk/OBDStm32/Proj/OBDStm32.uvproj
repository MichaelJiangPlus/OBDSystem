# Keil uVision project OBDStm32.uvproj, settings and files
target OBDStm32 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OBDStm32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\User;..\Bsp;..\Tab;..\Text
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: stm32f10x_it.c main.c ISO15765_4.c ISO14230_4.c ISO9141_2.c
  group Bsp
    ../Bsp/: delay.c Bsp.c LEDCommand.c
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_usart.c misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Tab
    ../Tab/: Tab.c
  group Text
    ../Text/: Chinese.c
